# Keil uVision project proj.uvprojx, settings and files
target LTBL Demo (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F051K6 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.0.1
  cpu: IROM(0x08000000,0x8000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: proj
  c flags: Optim=4 oTime=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F030
  c include: .\StdPeriphLibs;.\ArduinoAPI;.\ArduinoAPI\avr;.\Core;.\LTBL
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group User
    ./User/: main.cpp config.cpp
  group mdriver
    ./LTBL/: ltbl.c ltbl_signal.c ltbl_dshot.c ltbl_pwm.c
  group Applications
    ./User/: Identification.cpp
  group StdPeriph
    ./StdPeriphLibs/: stm32f0xx_adc.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group Arduino APIs
    ./ArduinoAPI/: HardwareSerial.cpp Print.cpp SPI.cpp Stream.cpp Tone.cpp Wire.cpp WireBase.cpp WMath.cpp WString.cpp Arduino.c itoa.c
    ./ArduinoAPI/avr/: dtostrf.c
  group Core
    ./Core/: adc.c delay.c exti.c gpio.c pwm.c timer.c
  group CMISS
    ./CMISS/: startup_stm32f0xx.s system_stm32f0xx.c
software components: CMSIS:CORE 3.40.0
